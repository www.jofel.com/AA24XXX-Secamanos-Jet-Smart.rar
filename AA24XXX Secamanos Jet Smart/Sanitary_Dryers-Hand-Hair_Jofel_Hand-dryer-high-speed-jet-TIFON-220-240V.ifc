Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Dryers-Hand-Hair_Jofel_Hand-dryer-high-speed-jet-TIFON-220-240V.ifc
Time: 2019-01-29T06:59:00
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Hand dryer high speed jet TIFON 220-240V 50/60Hz
ePset_BIMobjectScript - Colour: AA25050 - White; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Hand dryer high speed jet TIFON 220-240V 50/60Hz; SKU (BO_prodsku): hand_dryer_jet_tifon_220-240V_50-60hz; ManufacturName (BO_Manufac): Jofel; BrandUrl (BO_brandurl): http://jofel.com; ProductFamily (BO_prodfam): Hand dryers; ProductGroup (BO_prodgroup): Jet Tifon; ManufacturCountry (BO_mancont): Spain; DesignCountry (BO_designcont): Spain; EditionNumber (BO_edinum): 1; Width (BO_width): 320; Height (BO_height): 540; Depth (BO_depth): 180; Weight (BO_weight): 7.215; QR (BO_boqrurl): http://bimobject.com/jofel/product/hand_dryer_jet_tifon_220-240V_50-60hz; ProductDataUrl (BO_prodaturl): bimobject.com/jofel/product/hand_dryer_jet_tifon_220-240V_50-60hz; ProductUrl (BO_producturl): http://jofel.com/en/secamanos-jet-blanco-con-filtro-hepa-1508.html; InstallationInstructions (BO_montins): http://jofel.com/media/pdf/nuevasdescargas/Manual_Secamanos_Tifon_Jofel_v06.pdf; ProductCertification (BO_prodcert): http://jofel.com/media/pdf/nuevasdescargas/Cert_BE-7716_Jofel-Tifon.pdf; TechnicalDescription (BO_techcert): http://jofel.com/media/fichas/en/AA25050.pdf; InstructionVideo (BO_youtube): http://jofel.com/en/secamanos-jet-blanco-con-filtro-hepa-1508.html; EanCode (BO_ean): 8427950350566; MaterialMain (BO_mainmat): ABS; MaterialSecondary (BO_secmat): ABS; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Dryers (Hand & Hair); BimObjectCategoryCode (BO_bocat_code): sanitary-hand-and-hair-dryers; IfcClassification (BO_ifcclas): Electric Appliance; UnspcCode (BO_unspc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L82421; Uniclass14Description (BO_uniclass_1_4_desc): Hand driers; Uniclass20Code (BO_uniclass_2_0_code): SS-60-80; Uniclass20Description (BO_uniclass_2_0_desc): Drying Systems; Uniclass2015Code (BO_uniclass2015_code): Pr_40_70_62_37; Uniclass2015Description (BO_uniclass2015_desc): Hand driers; NBSReference (BO_nbs_ref): 60-80; NBSReferenceDescription (BO_nbs_desc): Drying Systems; OmniClassCode (BO_omniclass_code): 23-31 25 15; OmniClassDescription (BO_omniclass_name): Hand Dryers; UniFormat2Code (BO_uniformat2_code): E1020; UniFormat2Description (BO_uniformat2_name): Institutional Equipment; RegionEurope (BO_europe): AL, AT, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FR, GB, GR, HR, HU, IE, IT, LT, LU, LV, MD, ME, MK, NL, NO, PL, PT, RO, RS, RU, SE, SI, SK, UA; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, GF, GY, PE, PY, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BT, CN, GE, ID, IN, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MY, NP, PH, PK, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AU, FJ, NC, NZ, PG, SB, TL, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, DJ, DZ, EH, ER, ET, GA, GH, GN, GQ, GW, KE, LR, LS, LY, MA, MG, ML, MR, MW, MZ, NA, NE, NG, RW, SD, SL, SN, SO, SS, SZ, TD, TG, TN, TZ, UG, ZA, ZM, ZW
